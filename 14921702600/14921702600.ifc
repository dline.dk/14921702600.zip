Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: Project Number
Time: 2017-11-07T12:23:24
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20140606_1530(x64) - Exporter 2015.0.2014.0606 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Nov 07 12:23:24 2017 * Host: DESKTOP-FI6EGIK * Database: C:\Users\CERTIF~1\AppData\Local\Temp\{1C5F241B-3683-428F-B91D-651901DA7E1A}\ifc * Database version: 5507 * Database creation date: Tue Nov 07 12:23:23 2017 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Nov 07 12:23:24 2017 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Nov 07 12:23:24 2017 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 30, 344238; RefLongitude: -71, -3, -35, -194702; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other - Category: Levels; Family Name: Level; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints - Elevation: 0 mm; Elevation Base: Project Base Point
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no; Type Name: 8mm Head
Graphics - Color: 0; Line Pattern: Center; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcDoor: dline_Hardware_Locks_DeadLock_60mm_PZ72_Square, 14921702600b:dline_Hardware_Locks_DeadLock_60mm_PZ72_Square:194117
In: Level 1
Type - ParameterTakesPrecedence: no; Sizeable: no
Type - Analytical Properties - Analytic Construction: <None>
Type - Constraints - Default Elevation: 1219.2 mm
Type - Data - Backset: 60 mm; ClassificationGradesMinimumCategoryOfUse: V - Unsprung lever; ClassificationGradesMinimumCorrosionResistanceAndTemperature: n/a; ClassificationGradesMinimumDoorMassAndClosingForce: n/a; ClassificationGradesMinimumDurability: n/a; ClassificationGradesMinimumFieldOfDoorApplication: n/a; ClassificationGradesMinimumKeyIdentificationRequirement: n/a; ClassificationGradesMinimumSafety: n/a; ClassificationGradesMinimumSecurityAndDrillResistance: Q - Standard case; ClassificationGradesMinimumSuitabilityForUseOnFireAndSmokeDoors: n/a; ClassificationGradesMinimumTypeOfKeyOperationAndLocking: N - Normal; ClassificationGradesMinimumTypeOfSpindleOperation: n/a; Keying: n/a; LatchorLockType: Latch lock; LatchSpringStrength: n/a
Type - Dimensions - DoorLeafThickness: 40 mm; HandleClearance: 47 mm; HandleLength: 99 mm; HandleThickness: 30 mm; RoseDiameter: 50 mm; RoseHeight: 4 mm
Type - General - Author: Gytautas Balevičius; BIMObjectName: dline_Hardware_Locks_DeadLock_60mm_PZ72_Square; DesignCountry: n/a; ManufacturerName: d line; ManufacturerURL: www.dline.com; MasterFormat2014Code: 08 71 00; MasterFormat2014Description: Door hardware; NBSCertification: n/a; NBSDescription: Door and window locks and latches; NBSNote: n/a; NBSOfficeMasterTag: n/a; NBSReference: 45-25-18/310; NBSTypeID: n/a; OmniclassCode: 22-08 71 00; OmniclassDescription: Door Hardware; ProductFamily: Hardware; ProductGroup: Locks; ProductInformation: http://dline.com/product/knud-holscher-collection-dead-lock/?attribute_pa_material=satin-stainless-steel-aisi-316&attribute_pa_item=60-mm-pz72mm-square-strong-springstrike-plate#; ProductionCountry: n/a; ProductSKU: 14921702600; Revision: n/a; Uniclass2015Code: Pr_30_36_08_24; Uniclass2015Title: Door latches; Uniclass2015Version: Products v1.5; UNSPSCCode: 46171500; Version: 1; Weight Net (kg): 0
Type - Identity Data - Description: Dead lock 60 mm PZ 72 mm square, strong spring + strike plate; Manufacturer: info@dline.com; Type Mark: 22; Type Name: dline_Hardware_Locks_DeadLock_60mm_PZ72_Square
Type - Materials and Finishes - MainMaterial: AISI 304
Type - Other - Category: Doors; AccessibilityPerformance: n/a; AssetType: fixed; CodePerformance: n/a; Color: Steel; Constituents: Latch lock; DurationUnit: year; ExpectedLife: 20 years; Family Name: 14921702600b; Features: n/a; Finish: Satin; Grade: n/a; Material: Stainless steel AISI 304; ModelNumber: n/a; ModelReference: 45-25-18/310; Name: Locks_DeadLock_60mm_PZ72_Square; ReplacementCost: n/a; Shape: n/a; Size: 235 x 24 x 88 mm; SustainabilityPerformance: n/a; WarrantyDescription: 20 years (non-mechanical/-electronic parts) excluding labor; WarrantyDurationLabor: n/a; WarrantyDurationParts: 20; WarrantyDurationUnit: year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: claim@dline.com
OverallHeight: 89.5 mm; OverallWidth: 24 mm
Pset_DoorCommon - Reference: n/a; IsExternal: no; FireRating: n/a; AcousticRating: n/a; SecurityRating: n/a; HandicapAccessible: no; FireExit: no; SelfClosing: no; SmokeStop: no; GlazingAreaFraction: 0
Pset_ManufacturerTypeInformation - ModelReference: 45-25-18/310; Manufacturer: info@dline.com
Constraints - Elevation: 1219.2 mm; Host: <not associated>; Level: Level: Level 1
Dimensions - Area: 0.024342 m2; Volume: 0.00023571 m3
Identity Data - Mark: 1
Other - AssetIdentifier: n/a; BarCode: n/a; Family: 14921702600b: dline_Hardware_Locks_DeadLock_60mm_PZ72_Square; Family and Type: 14921702600b: dline_Hardware_Locks_DeadLock_60mm_PZ72_Square; InstallationDate: 1900-12-31T23:59:59; Schedule Level: Level: Level 1; SerialNumber: n/a; TagNumber: n/a; Type: 14921702600b: dline_Hardware_Locks_DeadLock_60mm_PZ72_Square; Type Id: 14921702600b: dline_Hardware_Locks_DeadLock_60mm_PZ72_Square; WarrantyStartDate: 1900-12-31T23:59:59
Phasing - Phase Created: New Construction
